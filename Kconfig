## Kconfig
```kconfig
config USR_DRV_HASH
  bool  "Userspace HASH driver"
  default y
  ---help---
  Support for STM32F4 HASH hardware IP.
```
